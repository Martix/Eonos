## conf/distro/include/eonos.inc
```bitbake
require conf/distro/include/angstrom.inc

DISTRO = "eonos"
DISTRO_NAME = "Eonos"

BUILDNAME = "Eonos ${DISTRO_VERSION}"

TARGET_VENDOR = "-eonos"
```
